# Repository Bhalddin/melzi

## EAGLE design melzi.brd

Parts:
B1: RESET; TACTILE_SWITCH_SMD
C1, C3, C4, C11, C13, C16, C18, C21, C23, C46, C49, C51: 0.1uF; CAPC2012X145AN
C2, C14, C19, C47: 0.22uF; CAPC2012X145AN
C5, C6, C7, C8, C9, C24: 4.7 uF; SMC_C
C10, C15, C20, C48: 10uF; CAPC2012X145AN
C12, C17, C22, C50: 100uF; PANASONIC_D
C27: .1uf; 0805
C28, C29, C30: 100 uF; UD-6,3X7,7_NICHICON
C31, C32, C43, C44: 0.1 uF; C1206
C41, C42: 1 uF; C1206
C45: 0.33 uF; C1206
IC5: 7805DT; TO252
IC6: ATMEGA1284P; TQFP44
IC7: 4050D; SO16
IC8: FT232RL-BASICSSOP; SSOP28DB
JP1: X-MOT; SCREWTERMINAL-3.5MM-4
JP2: Y-MOT; SCREWTERMINAL-3.5MM-4
JP3: Z-MOT; SCREWTERMINAL-3.5MM-4
JP4: E-MOT; SCREWTERMINAL-3.5MM-4
JP5: PWR; SCREWTERMINAL-5MM-2
JP6: BED; SCREWTERMINAL-5MM-2
JP7: END; SCREWTERMINAL-5MM-2
JP8: FAN; SCREWTERMINAL-5MM-2
JP9: X-STOP; SCREWTERMINAL-3.5MM-2
JP10: Y-STOP; SCREWTERMINAL-3.5MM-2
JP11: Z-STOP; SCREWTERMINAL-3.5MM-2
JP12: BEDTEMP; SCREWTERMINAL-3.5MM-2
JP13: ENDTEMP; SCREWTERMINAL-3.5MM-2
JP14: AUTO-RST; 1X02
JP15: VREG/USB; 1X03
JP16: M05X2PTH; AVR_ICSP
JP17: AVR_SPI_PRG_6PTH; 2X3
JS1: HOTBED_BYPASS; SJ_2S-NO
JS2: HOTEND_BYPASS; SJ_2S-NO
JS3: FAN_BYPASS; SJ_2S-NO
JS16: MS3; SJ_2S
L1: DEBUG; LED-1206
M1, M2, M3: RFP30N06LE; DPAK
MS-X, MS-X1, MS-X2, MS-X3: SOLDERJUMPER_2WAYCONNECTED; SJ_3_CONNECTED
Q1: 16MHZ; CSTCR6M
R1, R2, R3, R10, R11, R12: 10k; 1206
R4, R5: 4k7; 1206
R6, R8, R9, R27: 10k; RTRIM-ST4ETB
R7, R13, R18, R19, R22, R23, R28, R29: 0.11; RESC2012X70N
R14, R20, R24, R30: 10k; RESC2012X70N
R15, R21, R31, R36: 100k; RESC2012X70N
R16, R32, R34, R37: 4k7; RESC2012X70N
R17, R35, R38, R39: 20k; RESC2012X70N
R25, R26: 1K; 1206
R33: 200R; 0309V
U1, U2, U3, U4: A4982; TSSOP-24
X1: MICROSD
X2: MINI-USB-SHIELD-UX60-MB-5ST; UX60-MB-5ST

Connections:
!FAN: IC6.44 ((PCINT12/OC0B/!SS!)PB4), JS3.1, M3.1 (G), R12.1
!HOTBED: IC6.13 ((PCINT28/OC1B)PD4), JS1.1, M1.1 (G), R10.1
!HOTEND: IC6.14 ((PCINT29/OC1A)PD5), JS2.1, M2.1 (G), R11.1
!RESET: B1.3, B1.4, IC6.4 (RESET), JP14.1, JP17.5, R26.1
!XYEENABLE: IC6.15 ((PCINT30/OC2B/ICP)PD6), R15.2, R31.2, R36.2, U1.23 (!ENABLE), U2.23 (!ENABLE), U4.23 (!ENABLE)
!ZENABLE: IC6.32 ((PCINT5/ADC5)PA5), R21.2, U3.23 (!ENABLE)
AIFO: IC6.9 ((PCINT24/RXD0)PD0), IC8.1 (TXD)
AOFI: IC6.10 ((PCINT25/TXD0)PD1), IC8.5 (RXD)
BEDTEMP: C8.+, IC6.31 ((PCINT6/ADC6)PA6), JP12.1, R4.2
DTR: C32.1, IC8.2 (DTR)
E-DIR: IC6.40 ((PCINT8/XCK0/T0)PB0), U4.14 (DIR)
E-STEP: IC6.41 ((PCINT9/CLKO/T1)PB1), U4.11 (STEP)
ENDTEMP: C9.+, IC6.30 ((PCINT7/ADC7)PA7), JP13.1, R5.2
EXT-A1: IC6.36 ((PCINT1/ADC1)PA1), JP16.2
EXT-A2: IC6.35 ((PCINT2/ADC2)PA2), JP16.4
EXT-A3: IC6.34 ((PCINT3/ADC3)PA3), JP16.6
EXT-A4: IC6.33 ((PCINT4/ADC4)PA4), JP16.8, L1.A
EXT-RX1: IC6.11 ((PCINT26/INT0)PD2), JP16.7
EXT-SCL: IC6.19 ((PCINT16/SCL)PC0), JP16.3
EXT-SDA: IC6.20 ((PCINT17/SDA)PC1), JP16.1
EXT-TX1: IC6.12 ((PCINT27/INT1)PD3), JP16.5
GND: B1.1, B1.2, C2.1, C5.-, C6.-, C7.-, C8.-, C9.-, C10.1, C12.-, C13.2, C14.1, C15.1, C17.-, C18.2, C19.1, C20.1, C22.-, C23.2, C24.-, C27.2, C28.-, C29.-, C30.-, C31.1, C41.2, C42.2, C43.1, C44.2, C45.1, C47.1, C48.1, C50.-, C51.2, IC5.3 (GND), IC6.6 (GND), IC6.18 (GND), IC6.28 (GND), IC6.39 (GND), IC7.8 (VSS), IC8.7 (GND1), IC8.18 (GND2), IC8.21 (GND3), IC8.25 (AGND), IC8.26 (TEST), JP5.2, JP9.2, JP10.2, JP11.2, JP12.2, JP13.2, JP16.10, JP17.6, M1.3 (S), M2.3 (S), M3.3 (S), Q1.2, R6.1 (A), R7.2, R8.1 (A), R9.1 (A), R10.2, R11.2, R12.2, R13.2, R14.2, R18.2, R19.2, R20.2, R22.2, R23.2, R24.2, R25.2, R27.1 (A), R28.2, R29.2, R30.2, U1.13 (GND1), U1.24 (GND2), U1.PAD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
HOTBED-GND: JP6.2, JS1.2, M1.4 (D)
HOTBED-GND1: JP7.2, JS2.2, M2.4 (D)
HOTBED-GND2: JP8.2, JS3.2, M3.4 (D)
MISO: IC6.2 ((PCINT14/MISO)PB6), JP17.1, X1.7 (DATA_OUT)
MOSI: IC6.1 ((PCINT13/MOSI)PB5), IC7.3 (I), JP17.4
unnamed: C46.2, U2.1 (CP1)
unnamed: L1.C, R25.1
unnamed: C1.2, U1.1 (CP1)
unnamed: C46.1, U2.2 (CP2)
unnamed: R28.1, U2.17 (SENSE1)
unnamed: R29.1, U2.20 (SENSE2)
unnamed: R27.W (S), U2.12 (REF)
unnamed: R30.1, U2.8 (ROSC)
unnamed: C47.2, U2.4 (VREG)
unnamed: R32.2, U2.7 (!RESET), U2.9 (!SLEEP)
unnamed: C1.1, U1.2 (CP2)
unnamed: IC7.2 (O), X1.3 (DATA_IN)
unnamed: IC7.4 (O), X1.5 (SCLK)
unnamed: IC7.6 (O), X1.2 (CS)
unnamed: C27.1, IC5.2 (VO), JP15.3
unnamed: R7.1, U1.17 (SENSE1)
unnamed: R13.1, U1.20 (SENSE2)
unnamed: R6.W (S), U1.12 (REF)
unnamed: R14.1, U1.8 (ROSC)
unnamed: C3.2, U3.1 (CP1)
unnamed: C3.1, U3.2 (CP2)
unnamed: R18.1, U3.17 (SENSE1)
unnamed: C49.2, U2.3 (VCP)
unnamed: C4.2, U4.1 (CP1)
unnamed: C32.2, JP14.2
unnamed: C4.1, U4.2 (CP2)
unnamed: IC6.7 (XTAL2), Q1.1
unnamed: IC6.8 (XTAL1), Q1.3
unnamed: MS-X.1, U2.5 (MS1)
unnamed: MS-X.3, U2.6 (MS2)
unnamed: JP1.3, U2.18 (OUT1A)
unnamed: JP1.4, U2.15 (OUT1B)
unnamed: JP1.2, U2.19 (OUT2A)
unnamed: JP1.1, U2.22 (OUT2B)
unnamed: C24.+, IC5.1 (VI), JS16.1, R33.1
unnamed: C2.2, U1.4 (VREG)
unnamed: R16.2, U1.7 (!RESET), U1.9 (!SLEEP)
unnamed: C11.2, U1.3 (VCP)
unnamed: MS-X1.1, U1.5 (MS1)
unnamed: MS-X1.3, U1.6 (MS2)
unnamed: JP2.3, U1.18 (OUT1A)
unnamed: JP2.4, U1.15 (OUT1B)
unnamed: JP2.2, U1.19 (OUT2A)
unnamed: JP2.1, U1.22 (OUT2B)
unnamed: R6.2 (E), R17.1
unnamed: R19.1, U3.20 (SENSE2)
unnamed: R8.W (S), U3.12 (REF)
unnamed: R20.1, U3.8 (ROSC)
unnamed: C14.2, U3.4 (VREG)
unnamed: R34.2, U3.7 (!RESET), U3.9 (!SLEEP)
unnamed: C16.2, U3.3 (VCP)
unnamed: MS-X2.1, U3.5 (MS1)
unnamed: MS-X2.3, U3.6 (MS2)
unnamed: JP3.3, U3.18 (OUT1A)
unnamed: JP3.4, U3.15 (OUT1B)
unnamed: JP3.2, U3.19 (OUT2A)
unnamed: JP3.1, U3.22 (OUT2B)
unnamed: R8.2 (E), R35.1
unnamed: R22.1, U4.17 (SENSE1)
unnamed: R23.1, U4.20 (SENSE2)
unnamed: R9.W (S), U4.12 (REF)
unnamed: R24.1, U4.8 (ROSC)
unnamed: C19.2, U4.4 (VREG)
unnamed: R37.2, U4.7 (!RESET), U4.9 (!SLEEP)
unnamed: C21.2, U4.3 (VCP)
unnamed: MS-X3.1, U4.5 (MS1)
unnamed: MS-X3.3, U4.6 (MS2)
unnamed: R27.2 (E), R39.1
unnamed: JP4.3, U4.18 (OUT1A)
unnamed: JP4.4, U4.15 (OUT1B)
unnamed: JP4.2, U4.19 (OUT2A)
unnamed: JP4.1, U4.22 (OUT2B)
unnamed: R9.2 (E), R38.1
SCLK: IC6.3 ((PCINT15/SCK)PB7), IC7.5 (I), JP17.3
SD-SS: IC6.37 ((PCINT0/ADC0)PA0), IC7.7 (I)
USBDM: IC8.16 (USBDM), X2.2
USBDP: IC8.15 (USBDP), X2.3
UVCC: JP15.1, X2.1
VCC: C10.2, C15.2, C20.2, C41.1, C42.1, C43.2, C44.1, C45.2, C48.2, IC6.5 (VCC), IC6.17 (VCC), IC6.27 (AVCC), IC6.29 (AREF), IC6.38 (VCC), IC8.4 (VCCIO), IC8.20 (VCC), JP15.2, JP16.9, JP17.2, MS-X.2, MS-X1.2, MS-X2.2, MS-X3.2, R1.1, R2.1, R3.1, R4.1, R5.1, R15.1, R16.1, R17.2, R21.1, R26.2, R31.1, R32.1, R34.1, R35.2, R36.1, R37.1, R38.2, R39.2, U1.10 (VDD), U2.10 (VDD), U3.10 (VDD), U4.10 (VDD)
VDD: C31.2, IC7.1 (VDD), IC8.17 (3V3OUT), X1.4 (VDD)
VMOT: C11.1, C12.+, C13.1, C16.1, C17.+, C18.1, C21.1, C22.+, C23.1, C28.+, C29.+, C30.+, C49.1, C50.+, C51.1, JP5.1, JP6.1, JP7.1, JP8.1, JS16.2, R33.2, U1.16 (VBB1), U1.21 (VBB2), U2.16 (VBB1), U2.21 (VBB2), U3.16 (VBB1), U3.21 (VBB2), U4.16 (VBB1), U4.21 (VBB2)
X-DIR: IC6.24 ((PCINT21/TDI)PC5), U2.14 (DIR)
X-STEP: IC6.16 ((PCINT31/OC2A)PD7), U2.11 (STEP)
X-STOP: C5.+, IC6.21 ((PCINT18/TCK)PC2), JP9.1, R1.2
Y-DIR: IC6.26 ((PCINT23/TOSC2)PC7), U1.14 (DIR)
Y-STEP: IC6.25 ((PCINT22/TOSC1)PC6), U1.11 (STEP)
Y-STOP: C6.+, IC6.22 ((PCINT19/TMS)PC3), JP10.1, R2.2
Z-DIR: IC6.42 ((PCINT10/INT2/AIN0)PB2), U3.14 (DIR)
Z-STEP: IC6.43 ((PCINT11/OC0A/AIN1)PB3), U3.11 (STEP)
Z-STOP: C7.+, IC6.23 ((PCINT20/TDO)PC4), JP11.1, R3.2

Notes on the sheet:
VREG/USB SELECTOR
Motor Control X
Motor Control Y
Motor Control Z
Motor Control E

Board: 2 copper layers, 208.3 x 49.5 mm, 121 parts (0 on the bottom side), 117 nets.

File melzi-bom.csv (part):

Partlist

Exported from melzi.sch at 27/06/2012 18:33

EAGLE Version 6.2.0 Copyright (c) 1988-2012 CadSoft

Assembly variant: 

Part     Value                       Device                      Package               Library            Sheet

B1       RESET                       TAC_SWITCHSMD               TACTILE_SWITCH_SMD    SparkFun           1
C1       0.1uF                       CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C2       0.22uF                      CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C3       0.1uF                       CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C4       0.1uF                       CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C5       4.7 uF                      CPOL-EUSMCC                 SMC_C                 rcl                1
C6       4.7 uF                      CPOL-EUSMCC                 SMC_C                 rcl                1
C7       4.7 uF                      CPOL-EUSMCC                 SMC_C                 rcl                1
C8       4.7 uF                      CPOL-EUSMCC                 SMC_C                 rcl                1
C9       4.7 uF                      CPOL-EUSMCC                 SMC_C                 rcl                1
C10      10uF                        CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C11      0.1uF                       CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C12      100uF                       CPOL-USD                    PANASONIC_D           rcl                1
C13      0.1uF                       CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C14      0.22uF                      CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C15      10uF                        CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C16      0.1uF                       CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C17      100uF                       CPOL-USD                    PANASONIC_D           rcl                1
C18      0.1uF                       CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C19      0.22uF                      CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C20      10uF                        CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C21      0.1uF                       CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C22      100uF                       CPOL-USD                    PANASONIC_D           rcl                1
C23      0.1uF                       CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C24      4.7 uF                      CPOL-EUSMCC                 SMC_C                 rcl                1
C27      .1uf                        CAP0805                     0805                  SparkFun           1
C28      100 uF                      CPOL-EUUD-6,3X7,7           UD-6,3X7,7_NICHICON   rcl                1
C29      100 uF                      CPOL-EUUD-6,3X7,7           UD-6,3X7,7_NICHICON   rcl                1
C30      100 uF                      CPOL-EUUD-6,3X7,7           UD-6,3X7,7_NICHICON   rcl                1
C31      0.1 uF                      C-EUC1206                   C1206                 rcl                1
C32      0.1 uF                      C-EUC1206                   C1206                 rcl                1
C41      1 uF                        C-EUC1206                   C1206                 rcl                1
C42      1 uF                        C-EUC1206                   C1206                 rcl                1
C43      0.1 uF                      C-EUC1206                   C1206                 rcl                1
C44      0.1 uF                      C-EUC1206                   C1206                 rcl                1
C45      0.33 uF                     C-EUC1206                   C1206                 rcl                1
C46      0.1uF                       CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C47      0.22uF                      CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C48      10uF                        CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C49      0.1uF                       CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
C50      100uF                       CPOL-USD                    PANASONIC_D           rcl                1
C51      0.1uF                       CAPACITOR_0805              CAPC2012X145AN        ipc-7351-capacitor 1
IC5      7805DT                      7805DT                      TO252                 linear             1
IC6      ATMEGA1284P                 ATMEGA644A                  TQFP44                atmel              1
IC7      4050D                       4050D                       SO16                  40xx               1
IC8      FT232RL-BASICSSOP           FT232RL-BASICSSOP           SSOP28DB              SparkFun           1
JP1      X-MOT                       M04SCREW                    SCREWTERMINAL-3.5MM-4 SparkFun           1
JP2      Y-MOT                       M04SCREW                    SCREWTERMINAL-3.5MM-4 SparkFun           1
JP3      Z-MOT                       M04SCREW                    SCREWTERMINAL-3.5MM-4 SparkFun           1
JP4      E-MOT                       M04SCREW                    SCREWTERMINAL-3.5MM-4 SparkFun           1
JP5      PWR                         M025MM                      SCREWTERMINAL-5MM-2   SparkFun           1
JP6      BED                         M025MM                      SCREWTERMINAL-5MM-2   SparkFun           1
JP7      END                         M025MM                      SCREWTERMINAL-5MM-2   SparkFun           1
JP8      FAN                         M025MM                      SCREWTERMINAL-5MM-2   SparkFun           1
JP9      X-STOP                      M023.5MM                    SCREWTERMINAL-3.5MM-2 SparkFun           1
JP10     Y-STOP                      M023.5MM                    SCREWTERMINAL-3.5MM-2 SparkFun           1
JP11     Z-STOP                      M023.5MM                    SCREWTERMINAL-3.5MM-2 SparkFun           1
JP12     BEDTEMP                     M023.5MM                    SCREWTERMINAL-3.5MM-2 SparkFun           1
JP13     ENDTEMP                     M023.5MM                    SCREWTERMINAL-3.5MM-2 SparkFun           1
JP14     AUTO-RST                    M02PTH                      1X02                  SparkFun           1
JP15     VREG/USB                    M03PTH                      1X03                  SparkFun           1
JP16     M05X2PTH                    M05X2PTH                    AVR_ICSP              SparkFun           1
JP17     AVR_SPI_PRG_6PTH            AVR_SPI_PRG_6PTH            2X3                   SparkFun           1
JS1      HOTBED_BYPASS               JUMPER-2SMD-NO              SJ_2S-NO              SparkFun           1
JS2      HOTEND_BYPASS               JUMPER-2SMD-NO              SJ_2S-NO              SparkFun           1
JS3      FAN_BYPASS                  JUMPER-2SMD-NO              SJ_2S-NO              SparkFun           1
JS16     MS3                         JUMPER-2SMD-NC              SJ_2S                 SparkFun           1
L1       DEBUG                       LED1206                     LED-1206              SparkFun           1
M1       RFP30N06LE                  MOSFET-NCHANNELFDD8580      DPAK                  SparkFun           1
M2       RFP30N06LE                  MOSFET-NCHANNELFDD8580      DPAK                  SparkFun           1
M3       RFP30N06LE                  MOSFET-NCHANNELFDD8580      DPAK                  SparkFun           1
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
## Commit log

2012-06-16 Started replacing stepper driver chips.
2012-06-16 Melzi update wip
2012-06-17 New stepper drivers - X axis done.
2012-06-25 Y and Z drives added.
2012-06-26 Pretty much finalised. A couple of unrouted grounds need to be fixed.
2012-06-26 Melzi 2.0 finished (e&oe...)
2012-06-27 Thermistor resistors changed to 4K7.
2012-06-27 Gerbers and BOM added.
2012-06-28 Gaps between ground plane and tracks upped to 10 thou.
2012-06-30 Made motor current pots turn the right way.
2012-07-02 Gerbers for correct pot layout.
2012-07-02 Extensive rerouting to give 10 thou clearance between tracks.
2012-07-05 5V input solder link fixed.
2012-07-10 Component IDs better positioned on silkscreen.
2012-07-26 Added 0.33uF upstream of 5V reg. Specified 4.7uF cap in parallel as 30V.
2013-01-03 "Made in the UK" added to silkscreen.
2013-01-03 New silkscreen gerber.
2013-05-20 Correct resonator put in BoM.

Notices in the files:
melzi.brd:
reprappro.com RepRap Melzi V2.0  Licence: GPL Design: Joe Mosfet & Adrian
